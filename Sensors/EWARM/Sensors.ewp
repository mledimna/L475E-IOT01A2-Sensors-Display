# IAR project Sensors.ewp, settings and files
configuration Sensors (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L475xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; C:\Users\Mars03\STM32Cube\Repository\STM32Cube_FW_L4_V1.14.0\Drivers\BSP\B-L475E-IOT01; C:\Users\Mars03\STM32Cube\Repository\STM32Cube_FW_L4_V1.14.0\Drivers\BSP\Components\Common; C:\Users\Mars03\STM32Cube\Repository\STM32Cube_FW_L4_V1.14.0\Drivers\BSP\Components\hts221; C:\Users\Mars03\STM32Cube\Repository\STM32Cube_FW_L4_V1.14.0\Drivers\BSP\Components\lps22hb; C:\Users\Mars03\STM32Cube\Repository\STM32Cube_FW_L4_V1.14.0\Drivers\BSP\Components\lis3mdl; C:\Users\Mars03\STM32Cube\Repository\STM32Cube_FW_L4_V1.14.0\Drivers\BSP\Components\lsm6dsl
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Sensors.hex
  ILINK.IlinkOutputFile: Sensors.out
  ILINK.IlinkIcfFile: stm32l475xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l475xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/BSP/B-L475E-IOT01
    C:/Users/Mars03/STM32Cube/Repository/STM32Cube_FW_L4_V1.14.0/Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_accelero.c stm32l475e_iot01_gyro.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_magneto.c stm32l475e_iot01_psensor.c stm32l475e_iot01_tsensor.c
  group Drivers/BSP/Components
    C:/Users/Mars03/STM32Cube/Repository/STM32Cube_FW_L4_V1.14.0/Drivers/BSP/Components/hts221/: hts221.c
    C:/Users/Mars03/STM32Cube/Repository/STM32Cube_FW_L4_V1.14.0/Drivers/BSP/Components/lis3mdl/: lis3mdl.c
    C:/Users/Mars03/STM32Cube/Repository/STM32Cube_FW_L4_V1.14.0/Drivers/BSP/Components/lps22hb/: lps22hb.c
    C:/Users/Mars03/STM32Cube/Repository/STM32Cube_FW_L4_V1.14.0/Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_dfsdm.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_qspi.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c
